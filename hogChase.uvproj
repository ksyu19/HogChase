# Keil uVision project hogChase.uvproj, settings and files
target HogChase (ARM-ADS)
  device: TM4C1233H6PGE Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: hogChase
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Hardware and Device-Tethered Things
    ./: startup_TM4C123.s DAC.c ADC.c Sound.c ST7735.c TExaS.c Timer0.c Timer1.c Print.s LCD.s IO.s ADC.h tm4c123gh6pm.h TExaS.h
  group Software
    ./: organize.c Main.c
